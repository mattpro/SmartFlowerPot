# Keil uVision project SmartFlowerPot ver 2.1.uvprojx, settings and files
target CzujnikTemperatury (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: DoniczkaBluetooth +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF_LOG_USES_RTT BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  c include: .\src\nRF5_SDK_12.1.0\components\libraries\csense_drv\components;.\src\nRF5_SDK_12.1.0\components\libraries\csense_drv\components\ble\ble_advertising;.\src\nRF5_SDK_12.1.0\components\ble\ble_dtm;.\src\nRF5_SDK_12.1.0\components\ble\ble_racp;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_ancs_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_ans_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_bas;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_bas_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_cscs;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_cts_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_dfu;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_dis;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_gls;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_hids;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_hrs;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_hrs_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_hts;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_ias;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_ias_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_lbs;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_lbs_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_lls;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_nus;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_nus_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_rscs;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_rscs_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_tps;.\src\nRF5_SDK_12.1.0\components\ble\common;.\src\nRF5_SDK_12.1.0\components\ble\nrf_ble_qwr;.\src\nRF5_SDK_12.1.0\components\ble\peer_manager;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\adc;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\clock;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\common;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\comp;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\delay;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\gpiote;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\hal;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\i2s;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\lpcomp;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\pdm;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\ppi;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\pwm;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\qdec;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\rng;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\rtc;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\saadc;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\spi_master;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\spi_slave;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\swi;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\timer;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\twi_master;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\twis_slave;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\uart;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\wdt;.\src\nRF5_SDK_12.1.0\components\libraries\button;.\src\nRF5_SDK_12.1.0\components\libraries\crc16;.\src\nRF5_SDK_12.1.0\components\libraries\crc32;.\src\nRF5_SDK_12.1.0\components\libraries\csense;.\src\nRF5_SDK_12.1.0\components\libraries\csense_drv;.\src\nRF5_SDK_12.1.0\components\libraries\experimental_section_vars;.\src\nRF5_SDK_12.1.0\components\libraries\fds;.\src\nRF5_SDK_12.1.0\components\libraries\fifo;.\src\nRF5_SDK_12.1.0\components\libraries\fstorage;.\src\nRF5_SDK_12.1.0\components\libraries\hardfault;.\src\nRF5_SDK_12.1.0\components\libraries\hci;.\src\nRF5_SDK_12.1.0\components\libraries\led_softblink;.\src\nRF5_SDK_12.1.0\components\libraries\log;.\src\nRF5_SDK_12.1.0\components\libraries\log\src;.\src\nRF5_SDK_12.1.0\components\libraries\low_power_pwm;.\src\nRF5_SDK_12.1.0\components\libraries\mailbox;.\src\nRF5_SDK_12.1.0\components\libraries\mem_manager;.\src\nRF5_SDK_12.1.0\components\libraries\pwm;.\src\nRF5_SDK_12.1.0\components\libraries\scheduler;.\src\nRF5_SDK_12.1.0\components\libraries\slip;.\src\nRF5_SDK_12.1.0\components\libraries\timer;.\src\nRF5_SDK_12.1.0\components\libraries\twi;.\src\nRF5_SDK_12.1.0\components\libraries\uart;.\src\nRF5_SDK_12.1.0\components\libraries\util;.\src\nRF5_SDK_12.1.0\components\softdevice\common\softdevice_handler;.\src\nRF5_SDK_12.1.0\components\softdevice\s132\headers;.\src\nRF5_SDK_12.1.0\components\softdevice\s132\headers\nrf52;.\src\nRF5_SDK_12.1.0\components\toolchain;.\src\nRF5_SDK_12.1.0\examples\bsp;.\src\nRF5_SDK_12.1.0\external\segger_rtt;.\src;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\rtc;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\hal;.\src\nRF5_SDK_12.1.0\components\ble\ble_radio_notification;.\src\nRF5_SDK_12.1.0\components\softdevice\s132\headers\nrf52;.\src\nRF5_SDK_12.1.0\components\softdevice\s132\headers
  asm define: BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DSWI_DISABLE0
  asm include: ..\..\..\config\ble_app_beacon_pca10040_s132;..\..\..\config;.\src\nRF5_SDK_12.1.0\components;.\src\nRF5_SDK_12.1.0\components\ble\ble_advertising;.\src\nRF5_SDK_12.1.0\components\ble\ble_dtm;.\src\nRF5_SDK_12.1.0\components\ble\ble_racp;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_ancs_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_ans_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_bas;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_bas_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_cscs;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_cts_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_dfu;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_dis;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_gls;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_hids;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_hrs;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_hrs_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_hts;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_ias;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_ias_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_lbs;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_lbs_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_lls;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_nus;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_nus_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_rscs;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_rscs_c;.\src\nRF5_SDK_12.1.0\components\ble\ble_services\ble_tps;.\src\nRF5_SDK_12.1.0\components\ble\common;.\src\nRF5_SDK_12.1.0\components\ble\nrf_ble_qwr;.\src\nRF5_SDK_12.1.0\components\ble\peer_manager;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\adc;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\clock;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\common;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\comp;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\delay;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\gpiote;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\hal;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\i2s;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\lpcomp;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\pdm;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\ppi;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\pwm;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\qdec;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\rng;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\rtc;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\saadc;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\spi_master;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\spi_slave;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\swi;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\timer;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\twi_master;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\twis_slave;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\uart;.\src\nRF5_SDK_12.1.0\components\drivers_nrf\wdt;.\src\nRF5_SDK_12.1.0\components\libraries\button;.\src\nRF5_SDK_12.1.0\components\libraries\crc16;.\src\nRF5_SDK_12.1.0\components\libraries\crc32;.\src\nRF5_SDK_12.1.0\components\libraries\csense;.\src\nRF5_SDK_12.1.0\components\libraries\csense_drv;.\src\nRF5_SDK_12.1.0\components\libraries\experimental_section_vars;.\src\nRF5_SDK_12.1.0\components\libraries\fds;.\src\nRF5_SDK_12.1.0\components\libraries\fifo;.\src\nRF5_SDK_12.1.0\components\libraries\fstorage;.\src\nRF5_SDK_12.1.0\components\libraries\hardfault;.\src\nRF5_SDK_12.1.0\components\libraries\hci;.\src\nRF5_SDK_12.1.0\components\libraries\led_softblink;.\src\nRF5_SDK_12.1.0\components\libraries\log;.\src\nRF5_SDK_12.1.0\components\libraries\log\src;.\src\nRF5_SDK_12.1.0\components\libraries\low_power_pwm;.\src\nRF5_SDK_12.1.0\components\libraries\mailbox;.\src\nRF5_SDK_12.1.0\components\libraries\mem_manager;.\src\nRF5_SDK_12.1.0\components\libraries\pwm;.\src\nRF5_SDK_12.1.0\components\libraries\scheduler;.\src\nRF5_SDK_12.1.0\components\libraries\slip;.\src\nRF5_SDK_12.1.0\components\libraries\timer;.\src\nRF5_SDK_12.1.0\components\libraries\twi;.\src\nRF5_SDK_12.1.0\components\libraries\uart;.\src\nRF5_SDK_12.1.0\components\libraries\util;.\src\nRF5_SDK_12.1.0\components\softdevice\common\softdevice_handler;.\src\nRF5_SDK_12.1.0\components\softdevice\s132\headers;.\src\nRF5_SDK_12.1.0\components\softdevice\s132\headers\nrf52;.\src\nRF5_SDK_12.1.0\components\toolchain;..\..\..\..\..\bsp;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20001930 size 0xe6d0
  group Application
    ./src/: main.c config.h sdk_config.h config.c myAdc.c myRtc.c
  group nRF_BLE
    ./src/nRF5_SDK_12.1.0/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ./src/nRF5_SDK_12.1.0/components/ble/ble_radio_notification/: ble_radio_notification.c
  group nRF_Drivers
    ./src/nRF5_SDK_12.1.0/components/drivers_nrf/clock/: nrf_drv_clock.c
    ./src/nRF5_SDK_12.1.0/components/drivers_nrf/common/: nrf_drv_common.c
    ./src/nRF5_SDK_12.1.0/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ./src/nRF5_SDK_12.1.0/components/drivers_nrf/uart/: nrf_drv_uart.c
    ./src/nRF5_SDK_12.1.0/components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ./src/nRF5_SDK_12.1.0/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ./src/nRF5_SDK_12.1.0/components/drivers_nrf/hal/: nrf_saadc.c
  group nRF_Libraries
    ./src/nRF5_SDK_12.1.0/components/libraries/button/: app_button.c
    ./src/nRF5_SDK_12.1.0/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ./src/nRF5_SDK_12.1.0/components/libraries/fifo/: app_fifo.c
    ./src/nRF5_SDK_12.1.0/components/libraries/timer/: app_timer.c
    ./src/nRF5_SDK_12.1.0/components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ./src/nRF5_SDK_12.1.0/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ./src/nRF5_SDK_12.1.0/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ./src/nRF5_SDK_12.1.0/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_3.0.0_softdevice (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_beacon_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20001930 size 0xe6d0
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
